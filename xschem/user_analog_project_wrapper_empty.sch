v {xschem version=3.0.0 file_version=1.2 }
G {}
K {}
V {}
S {}
E {}
C {devices/iopin.sym} 50 -300 0 0 {name=p1 lab=vdda1}
C {devices/iopin.sym} 50 -270 0 0 {name=p2 lab=vdda2}
C {devices/iopin.sym} 50 -240 0 0 {name=p3 lab=vssa1}
C {devices/iopin.sym} 50 -210 0 0 {name=p4 lab=vssa2}
C {devices/iopin.sym} 50 -180 0 0 {name=p5 lab=vccd1}
C {devices/iopin.sym} 50 -150 0 0 {name=p6 lab=vccd2}
C {devices/iopin.sym} 50 -120 0 0 {name=p7 lab=vssd1}
C {devices/iopin.sym} 50 -90 0 0 {name=p8 lab=vssd2}
C {devices/ipin.sym} 100 -20 0 0 {name=p9 lab=wb_clk_i}
C {devices/ipin.sym} 100 10 0 0 {name=p10 lab=wb_rst_i}
C {devices/ipin.sym} 100 40 0 0 {name=p11 lab=wbs_stb_i}
C {devices/ipin.sym} 100 70 0 0 {name=p12 lab=wbs_cyc_i}
C {devices/ipin.sym} 100 100 0 0 {name=p13 lab=wbs_we_i}
C {devices/ipin.sym} 100 130 0 0 {name=p14 lab=wbs_sel_i[3:0]}
C {devices/ipin.sym} 100 160 0 0 {name=p15 lab=wbs_dat_i[31:0]}
C {devices/ipin.sym} 100 190 0 0 {name=p16 lab=wbs_adr_i[31:0]}
C {devices/opin.sym} 90 250 0 0 {name=p17 lab=wbs_ack_o}
C {devices/opin.sym} 90 280 0 0 {name=p18 lab=wbs_dat_o[31:0]}
C {devices/ipin.sym} 100 320 0 0 {name=p19 lab=la_data_in[127:0]}
C {devices/opin.sym} 90 350 0 0 {name=p20 lab=la_data_out[127:0]}
C {devices/ipin.sym} 100 430 0 0 {name=p21 lab=io_in[26:0]}
C {devices/ipin.sym} 100 460 0 0 {name=p22 lab=io_in_3v3[26:0]}
C {devices/ipin.sym} 90 740 0 0 {name=p23 lab=user_clock2}
C {devices/opin.sym} 90 490 0 0 {name=p24 lab=io_out[26:0]}
C {devices/opin.sym} 90 520 0 0 {name=p25 lab=io_oeb[26:0]}
C {devices/iopin.sym} 60 580 0 0 {name=p26 lab=gpio_analog[17:0]}
C {devices/iopin.sym} 60 610 0 0 {name=p27 lab=gpio_noesd[17:0]}
C {devices/iopin.sym} 60 640 0 0 {name=p29 lab=io_analog[10:0]}
C {devices/iopin.sym} 60 670 0 0 {name=p30 lab=io_clamp_high[2:0]}
C {devices/iopin.sym} 60 700 0 0 {name=p31 lab=io_clamp_low[2:0]}
C {devices/opin.sym} 80 770 0 0 {name=p32 lab=user_irq[2:0]}
C {devices/ipin.sym} 100 380 0 0 {name=p28 lab=la_oenb[127:0]}
